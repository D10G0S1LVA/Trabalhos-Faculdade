# Repository D10G0S1LVA/Trabalhos-Faculdade

File README.md:

# Trabalhos-Faculdade
Rep para guardar projetos e trabalhos desenvolvidos na faculdade

## KiCad design CTeSP/Projeto de Sistemas Eletrónicos (PSE)/Projeto/Projeto/GPU_Projeto.kicad_pcb

File CTeSP/Projeto de Sistemas Eletrónicos (PSE)/Projeto/Readme.md:

# Laboratório 5 de Projeto de Sistemas Eletrónicos (PSE)

Mais uma vez, recorreu-se ao programa KiCad, uma ferramenta gratuita e Open Source.

Foi dada a liberdade de escolher qualquer circuito para o projeto. Foi escolhido fazer um Mini computador

[Inspiração para o projeto](https://eater.net/6502).

[Para mais detalhes, o ficheiro do Relatório poderá ser útil](https://github.com/D10G0S1LVA/Trabalhos-Faculdade/blob/main/CTeSP/Projeto%20de%20Sistemas%20Eletr%C3%B3nicos%20(PSE)/Projeto/PSE%20Projecto%20Final.docx).

Foram criados e desenhados novos simbolos.

O esquema principal é o seguinte:

O esquema dentro do bloco *Computador* é:

Dentro do bloco *Video Out* (Localizado inferiormente) é:

Desenho da *PCB*:

Foram utilizadas várias camadas:

Placa em 3D gerada pelo programa:

Bottom side para ser observar as pistas:

Board: 4 copper layers, 148.6 x 177.8 mm, 77 parts (0 on the bottom side), 126 nets.

Parts:
C1: 470uF; CP_Radial_D6.3mm_P2.50mm
C2, C3, C4, C5, C6, C7: 0.1uF; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D4: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
F1: Fuse
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_DIN965_Pad
HS1: Heatsink_Pad; Heatsink_Stonecold_HS-132_32x14mm_2xFixation1.5mm
J1: Screw_Terminal_01x02; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J2: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J4: USB_A; USB_A_CNCTech_1001-011-01101_Horizontal
J5: DB15_Female_HighDensity; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03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
R1: 1k; R_0603_1608Metric
R2, R6, R8, R10: 1K; R_0603_1608Metric
R3, R5, R12: 270; R_0603_1608Metric
R7, R9, R11: 680; R_0603_1608Metric
RV1: R_POT; Potentiometer_Bourns_3296Z_Horizontal
SW1: SW_Push; SW_SPST_PTS645
T1: Transformer_1P_1S; Transformador 230V para 12V AC
U1: LM1085-5.0; TO-262-3_Vertical
U2: W65C02; DIP-40_W15.24mm
U3, U6: 74HC00; SOIC-14_3.9x8.7mm_P1.27mm
U4: MAX7375AXR105; SOT-323_SC-70
U5: 28C256; DIP-28_W7.62mm_LongPads
U7: 62256; DIP-28_W7.62mm
U8: WD65C22; DIP-40_W15.24mm
U9: 16x2_LCD; HY1602E
U10, U24, U25, U26, U27, U37, U38, U39, U40: 74LS00; SOIC-14_3.9x8.7mm_P1.27mm
U11: 74HC74; SOIC-14_3.9x8.7mm_P1.27mm
U12, U13, U14: 74LS245; SO-20_12.8x7.5mm_P1.27mm
U15, U16, U17, U28, U29, U30: 74LS161; HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm
U18, U19, U21, U31, U32, U34: 74LS04; SOIC-14_3.9x8.7mm_P1.27mm
U20, U22, U23, U33, U35, U36: 74LS30; SOIC-14_3.9x8.7mm_P1.27mm
X1: Clock; SOT-323_SC-70

Connections:
+5V: C4.1, C6.1, C7.1, J2.1, J3.A4, J3.A9, J3.B4, J3.B9, J4.1, U5.27, U5.28, U7.28, U8.20, U9.1, U9.15, U11.10, U11.13, U12.1, U12.20, U13.1, U13.7, U13.20, U14.20, U15.7, U15.9, U15.10, U15.16, U16.7, U16.9, U16.16, U17.7, U17.9, U17.16, U28.7, U28.9, U28.10, U28.16, U29.7, U29.9, U29.16, U30.7, U30.9, U30.16, X1.1
/Computador/Video Out/Blue: J5.3, R6.2, R7.2
/Computador/Video Out/Green: J5.2, R8.2, R9.2
/Computador/Video Out/Red: J5.1, R10.2, R11.2
/Computador/Video Out/Sincronização Horizontal/264: U15.2, U16.2, U17.2, U28.1, U29.1, U30.1, U36.8, U40.1
/Computador/Video Out/Sincronização Horizontal/(~HBLANK~): U10.5, U38.1, U40.3
/Computador/Video Out/Sincronização Horizontal/CLK: U28.2, U29.2, U30.2, X1.2
/Computador/Video Out/Sincronização Horizontal/HSync: J5.13, U37.1, U39.3
/Computador/Video Out/Sincronização Horizontal/Q0: U18.1, U28.14
/Computador/Video Out/Sincronização Horizontal/Q1: U12.2, U18.3, U28.13, U34.11, U35.11
/Computador/Video Out/Sincronização Horizontal/Q2: U12.3, U18.5, U28.12
/Computador/Video Out/Sincronização Horizontal/Q3: U12.4, U19.9, U28.11, U33.2, U36.1
/Computador/Video Out/Sincronização Horizontal/Q4: U12.5, U29.14, U31.11, U34.3
/Computador/Video Out/Sincronização Horizontal/Q5: U12.6, U29.13, U31.9, U35.4
/Computador/Video Out/Sincronização Horizontal/Q6: U12.7, U29.12, U31.13, U33.5, U34.5, U35.5
/Computador/Video Out/Sincronização Horizontal/Q7: U12.8, U29.11, U32.11, U33.6, U34.6, U35.6
/Computador/Video Out/Sincronização Horizontal/Q8: U30.14, U32.9, U36.6
/Computador/Video Out/Sincronização Vertical/(~VBLANK~): U25.1, U27.3
/Computador/Video Out/Sincronização Vertical/Q0: U15.14, U18.13, U21.2, U22.2
/Computador/Video Out/Sincronização Vertical/Q1: U15.13, U18.11
/Computador/Video Out/Sincronização Vertical/Q2: U15.12, U18.9, U22.4, U23.4
/Computador/Video Out/Sincronização Vertical/Q3: U12.9, U15.11, U19.13, U20.5, U21.5, U22.5
/Computador/Video Out/Sincronização Vertical/Q4: U13.2, U16.14, U20.12, U21.12, U22.12, U23.12
/Computador/Video Out/Sincronização Vertical/Q5: U13.3, U16.13, U19.11, U23.6
/Computador/Video Out/Sincronização Vertical/Q6: U13.4, U16.12, U20.11, U21.11, U22.11, U23.11
/Computador/Video Out/Sincronização Vertical/Q7: U13.5, U16.11
/Computador/Video Out/Sincronização Vertical/Q8: U13.6, U17.14
/Computador/Video Out/Sincronização Vertical/Q9: U10.1, U10.2, U17.13, U20.1, U21.1, U22.1, U23.1
/Computador/Video Out/Sincronização Vertical/VSync: J5.14, U24.1, U26.3
/Computador/Video Out/~CPU_CLK: U3.3, U11.11
/Computador/Video Out/~DMA: U2.2, U2.36, U6.10, U11.9, U12.19, U13.19
/Computador/a0: U2.9, U5.10, U7.10, U8.38, U12.18
/Computador/a1: U2.10, U5.9, U7.9, U8.37, U12.17
/Computador/a2: U2.11, U5.8, U7.8, U8.36, U12.16
/Computador/a3: U2.12, U5.7, U7.7, U8.35, U12.15
/Computador/a4: U2.13, U5.6, U7.6, U12.14
/Computador/a5: U2.14, U5.5, U7.5, U12.13
/Computador/a6: U2.15, U5.4, U7.4, U12.12
/Computador/a7: U2.16, U5.3, U7.3, U12.11
/Computador/a8: U2.17, U5.25, U7.25, U13.18
/Computador/a9: U2.18, U5.24, U7.24, U13.17
/Computador/a10: U2.19, U5.21, U7.21, U13.16
/Computador/a11: U2.20, U5.23, U7.23, U13.15
/Computador/a12: U2.22, U5.2, U7.2, U13.14
/Computador/a13: U2.23, U5.26, U7.26, U8.24, U13.13
/Computador/a14: U2.24, U3.4, U5.1, U7.1, U7.22, U13.12
/Computador/a15: U2.25, U3.12, U3.13, U13.11
/Computador/d0: U2.33, U5.11, U7.11, U8.33, U14.18
/Computador/d1: U2.32, U5.12, U7.12, U8.32, U14.17
/Computador/d2: U2.31, U5.13, U7.13, U8.31, U14.16
/Computador/d3: U2.30, U5.15, U7.15, U8.30, U14.15
/Computador/d4: U2.29, U5.16, U7.16, U8.29, U14.14
/Computador/d5: U2.28, U5.17, U7.17, U8.28, U14.13
/Computador/d6: U2.27, U5.18, U7.18, U8.27
/Computador/d7: U2.26, U5.19, U7.19, U8.26
/PSU/+5V: C3.1, R1.2, U1.2, U2.6, U2.8, U4.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D2.1, D4.2, HS1.1, J2.4, J2.5, J2.6, J3.A1, J3.A5, J3.A12, J3.B1, J3.B5, J3.B12, J3.S1, J4.4, J4.5, J5.5, J5.6, J5.7, J5.8, J5.10, RV1.1, SW1.1, U1.1, U2.21, U4.3, U5.14, U5.22, U7.14, U8.1, U9.2, U9.16, U12.10, U13.8, U13.9, U13.10, U14.1, U14.10, U15.8, U16.8, U17.8, U28.8, U29.8, U30.8, X1.3
unnamed: C1.1, C2.1, D3.1, D4.1, U1.3
unnamed: C5.1, R1.1, R2.1, SW1.2, U2.40, U8.34
unnamed: D1.1, D3.2, F1.1
unnamed: D1.2, D2.2, T1.3
unnamed: F1.2, T1.4
unnamed: J1.1, T1.1
unnamed: J1.2, T1.2
unnamed: J2.2, J3.A7, J3.B7, J4.2, U8.4
unnamed: J2.3, R3.2
unnamed: J3.A6, J3.B6, R12.2
unnamed: J4.3, R5.2
unnamed: R2.2, U2.34, U3.9, U7.27, U8.22
unnamed: R3.1, U8.3
unnamed: R5.1, U8.6
unnamed: R6.1, U14.2
unnamed: R7.1, U14.3
unnamed: R8.1, U14.4
unnamed: R9.1, U14.5
unnamed: R10.1, U14.6
unnamed: R11.1, U14.7
unnamed: R12.1, U8.5
unnamed: RV1.2, U9.3
unnamed: U2.4, U8.21
unnamed: U2.37, U3.1, U3.2, U4.2, U8.25
unnamed: U3.6, U8.23
unnamed: U3.8, U6.9
unnamed: U3.5, U3.10, U3.11, U5.20
unnamed: U6.8, U7.20
unnamed: U8.7, U9.4
unnamed: U8.8, U9.5
unnamed: U8.9, U9.6
unnamed: U8.10, U9.7
unnamed: U8.11, U9.8
unnamed: U8.12, U9.9
unnamed: U8.13, U9.10
unnamed: U8.14, U9.11
unnamed: U8.15, U9.12
unnamed: U8.16, U9.13
unnamed: U8.17, U9.14
unnamed: U10.3, U10.4
unnamed: U10.6, U11.12, U14.19
unnamed: U15.1, U16.1, U17.1, U23.8, U27.1
unnamed: U15.15, U16.10
unnamed: U16.15, U17.10
unnamed: U18.2, U33.12, U34.12, U35.12
unnamed: U18.4, U33.11, U36.12
unnamed: U18.6, U33.1, U34.1, U35.1, U36.11
unnamed: U18.8, U20.4, U21.4
unnamed: U18.10, U20.3, U21.3, U22.3, U23.3
unnamed: U18.12, U20.2, U23.2
unnamed: U19.8, U33.3, U34.2, U35.2
unnamed: U19.10, U20.6, U21.6, U22.6
unnamed: U19.12, U23.5
unnamed: U20.8, U25.2
unnamed: U21.8, U26.1
unnamed: U22.8, U24.2
unnamed: U24.3, U26.2
unnamed: U25.3, U27.2
unnamed: U28.15, U29.10
unnamed: U29.15, U30.10
unnamed: U31.8, U33.4, U34.4, U36.3
unnamed: U31.10, U35.3, U36.2
unnamed: U31.12, U36.4
unnamed: U32.10, U36.5
unnamed: U33.8, U38.2
unnamed: U34.8, U39.1
unnamed: U35.8, U37.2
unnamed: U37.3, U39.2
unnamed: U38.3, U40.2

## KiCad design CTeSP/Projeto de Sistemas Eletrónicos (PSE)/Lab_5_PSE/Circuito/Lab5-Diogo_Silva.kicad_pcb

File CTeSP/Projeto de Sistemas Eletrónicos (PSE)/Lab_5_PSE/Readme.md:

# Laboratório 5 de Projeto de Sistemas Eletrónicos (PSE)

Utilizou-se o programa KiCad, uma ferramenta gratuita e Open Source.

No presente Laboratório, criou-se uma *Shield* para o *Arduino Uno*, que contém 1x display de 7 Segmentos, Potenciômetro, *LED's*, *Bluetooth*, botões e Sensor de Temperatura.

Foi um desafio fazer a *PCB* deste circuito porque é necessário respeitar as medidas da placa.

Foram criados e desenhados alguns novos simbolos.

Não contém relatório.

O esquema é o seguinte:

Desenho da *PCB*:

Placa em 3D gerada pelo programa:

Bottom side para ser observar as pistas:

Parts:
P5, P6, P7, P8: CONN_01X01; Arduino_1pin

Notes on the sheet:
Holes

Parts:
R5, R6, R23: 4K7; R_1206_3216Metric
SW1, SW2, SW3: SW_Push; SW_PUSH_6mm_H4.3mm

Connections:
+5V: SW1.1, SW2.1, SW3.1; also elsewhere on the board
/Button/Key0: R23.2, SW3.2; also elsewhere on the board
/Button/Key1: R6.2, SW2.2; also elsewhere on the board
/Button/Key2: R5.2, SW1.2; also elsewhere on the board
GND: R5.1, R6.1, R23.1; also elsewhere on the board

Notes on the sheet:
Botão

Parts:
D1: Green; LED_Rectangular_W5.0mm_H5.0mm
D2: Yellow; LED_Rectangular_W5.0mm_H5.0mm
D3: RED; LED_D8.0mm
R2, R3, R4: 270; R_1206_3216Metric

Connections:
/LED/LED0: R2.1; also elsewhere on the board
/LED/LED1: R3.1; also elsewhere on the board
/LED/LED2: R4.1; also elsewhere on the board
GND: D1.1 (K), D2.1 (K), D3.1 (K); also elsewhere on the board
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), R4.2

Notes on the sheet:
LED's

Parts:
C3, C4: 100nF; C_Disc_D9.0mm_W5.0mm_P5.00mm
R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22: 270; R_1206_3216Metric
S2, S3: LCD_7Segmentos; 7Segments11
U2, U3: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C3.1, C4.1, S2.3 (K), S2.8 (K), S3.3 (K), S3.8 (K), U2.16 (VCC), U3.16 (VCC); also elsewhere on the board
/LCD_7Segm/Clear: U2.10 (~SRCLR), U3.10 (~SRCLR); also elsewhere on the board
/LCD_7Segm/LE1: U2.12 (RCLK); also elsewhere on the board
/LCD_7Segm/OE1: U2.13 (~OE); also elsewhere on the board
/LCD_7Segm/OE2: U3.13 (~OE); also elsewhere on the board
/LCD_7Segm/SClk: U2.11 (SRCLK), U3.11 (SRCLK); also elsewhere on the board
/LCD_7Segm/SData: U2.14 (SER), U3.14 (SER); also elsewhere on the board
/Shield Arduino Uno/LE1: U3.12 (RCLK); also elsewhere on the board
GND: C3.2, C4.2, U2.8 (GND), U3.8 (GND); also elsewhere on the board
unnamed: R7.1, S2.7 (Segm_A)
unnamed: R7.2, U2.15 (QA)
unnamed: R8.1, S2.6 (Segm_B)
unnamed: R8.2, U2.1 (QB)
unnamed: R9.1, S2.4 (Segm_C)
unnamed: R9.2, U2.2 (QC)
unnamed: R10.1, S2.2 (Segm_D)
unnamed: R10.2, U2.3 (QD)
unnamed: R11.1, S2.1 (Segm_E)
unnamed: R11.2, U2.4 (QE)
unnamed: R12.1, S2.9 (Segm_F)
unnamed: R12.2, U2.5 (QF)
unnamed: R13.1, S2.10 (Segm_G)
unnamed: R13.2, U2.6 (QG)
unnamed: R14.1, S2.5 (Segm_DP)
unnamed: R14.2, U2.7 (QH)
unnamed: R15.1, S3.7 (Segm_A)
unnamed: R15.2, U3.15 (QA)
unnamed: R16.1, S3.6 (Segm_B)
unnamed: R16.2, U3.1 (QB)
unnamed: R17.1, S3.4 (Segm_C)
unnamed: R17.2, U3.2 (QC)
unnamed: R18.1, S3.2 (Segm_D)
unnamed: R18.2, U3.3 (QD)
unnamed: R19.1, S3.1 (Segm_E)
unnamed: R19.2, U3.4 (QE)
unnamed: R20.1, S3.9 (Segm_F)
unnamed: R20.2, U3.5 (QF)
unnamed: R21.1, S3.10 (Segm_G)
unnamed: R21.2, U3.6 (QG)
unnamed: R22.1, S3.5 (Segm_DP)
unnamed: R22.2, U3.7 (QH)

Notes on the sheet:
Bloco de LCD de 7 Segmentos

Parts:
C1, C2: 100nF; C_Disc_D9.0mm_W5.0mm_P5.00mm
RV1, RV2: POT; Potentiometer_Bourns_3299Z_Horizontal

Connections:
+5V: RV1.3, RV2.1; also elsewhere on the board
/Potenciometro/Pot1: C1.1, RV1.2; also elsewhere on the board
/Potenciometro/Pot2: C2.1, RV2.2; also elsewhere on the board
GND: C1.2, C2.2, RV1.1, RV2.3; also elsewhere on the board

Notes on the sheet:
Potênciometro

Parts:
R1: 4K7; R_1206_3216Metric
U1: DS1820; TO-92L_Wide

Connections:
+5V: R1.1, U1.3 (VCC); also elsewhere on the board
/Shield Arduino Uno/Temp: R1.2, U1.2 (DQ); also elsewhere on the board
GND: U1.1 (GND); also elsewhere on the board

Notes on the sheet:
Sensor de Temperatura

Parts:
P0: Bluetooth + Serial; PinSocket_1x06_P2.54mm_Vertical

Connections:
+5V: P0.1; also elsewhere on the board
/Bluetooth + Serial/BT1: P0.4; also elsewhere on the board
/Bluetooth + Serial/BT2: P0.3; also elsewhere on the board
/Bluetooth + Serial/RX: P0.6; also elsewhere on the board
/Bluetooth + Serial/TX: P0.5; also elsewhere on the board
GND: P0.2; also elsewhere on the board

Notes on the sheet:
Módulo Bluetooth com Ligação Serial

Parts:
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08

Connections:
+5V: P1.5; also elsewhere on the board
/Bluetooth + Serial/BT1: P4.6; also elsewhere on the board
/Bluetooth + Serial/BT2: P4.5; also elsewhere on the board
/Bluetooth + Serial/RX: P4.8; also elsewhere on the board
/Bluetooth + Serial/TX: P4.7; also elsewhere on the board
/Button/Key0: P2.3; also elsewhere on the board
/Button/Key1: P2.4; also elsewhere on the board
/Button/Key2: P2.5; also elsewhere on the board
/LCD_7Segm/Clear: P3.7; also elsewhere on the board
/LCD_7Segm/LE1: P3.8; also elsewhere on the board
/LCD_7Segm/OE1: P4.1; also elsewhere on the board
/LCD_7Segm/OE2: P3.10; also elsewhere on the board
/LCD_7Segm/SClk: P3.6; also elsewhere on the board
/LCD_7Segm/SData: P3.5; also elsewhere on the board
/LED/LED0: P4.4; also elsewhere on the board
/LED/LED1: P4.3; also elsewhere on the board
/LED/LED2: P4.2; also elsewhere on the board
/Potenciometro/Pot1: P2.2; also elsewhere on the board
/Potenciometro/Pot2: P2.6; also elsewhere on the board
/Shield Arduino Uno/AREF: P3.3
/Shield Arduino Uno/LE1: P3.9; also elsewhere on the board
/Shield Arduino Uno/SCL: P3.1
/Shield Arduino Uno/SDA: P3.2
/Shield Arduino Uno/Temp: P2.1; also elsewhere on the board
GND: P1.6, P1.7, P3.4; also elsewhere on the board

Notes on the sheet:
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.

Board: 4 copper layers, 68.6 x 53.3 mm, 49 parts (0 on the bottom side), 57 nets.
