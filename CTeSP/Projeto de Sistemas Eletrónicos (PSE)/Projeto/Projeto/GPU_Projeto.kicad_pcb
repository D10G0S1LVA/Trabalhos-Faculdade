# Repository D10G0S1LVA/Trabalhos-Faculdade (continued)

## KiCad design CTeSP/Projeto de Sistemas Eletrónicos (PSE)/Lab_4_PSE/Lab 4 PSE.kicad_pcb

File CTeSP/Projeto de Sistemas Eletrónicos (PSE)/Lab_4_PSE/Readme.md:

# Laboratório 4 de Projeto de Sistemas Eletrónicos (PSE)

Utilizou-se o programa KiCad, uma ferramenta gratuita e Open Source.

No presente Laboratório, criou-se um Indicador de Volume de Audio, ou, abreviando, Vuímetro / VU-Meter.

Foram criados e desenhados novos simbolos.

Não contém relatório, em contapartida, foi a introdução para o desenho na *PCB*.

O esquema é o seguinte:

Desenho da *PCB*:

Placa em 3D gerada pelo programa:

Bottom side para ser observar as pistas:

Parts:
C101, C102: 47uF; C_Radial_D5.0mm_H11.0mm_P2.00mm
C103, C104, C105: 100nF; C_Disc_D10.0mm_W2.5mm_P5.00mm
D98, D103: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D99: D_Schottky; D_A-405_P7.62mm_Horizontal
D100, D101, D104, D105, D107, D111, D112, D113, D114, D116: LED; LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
D102: DZ2S051X0L; D_A-405_P7.62mm_Horizontal
FID1, FID2: Fiducial; Fiducial_0.5mm_Mask1.5mm
H101, H102, H103, H104: MountingHole; MountingHole_2.2mm_M2
J101: Screw_Terminal_01x02; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J102: Screw_Terminal_01x03; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
J103: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
R13: 470K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R101, R102, R104: 47K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R103: 330; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R105, R110, R111, R112, R113, R114, R115, R116, R117, R118: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R106: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R107: 2.2K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R108: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R119: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV101: R_POT_Small; Potentiometer_ACP_CA9-H3,8_Horizontal
U101: LM741; DIP-8_W7.62mm_Socket_LongPads
U102: LM3915; DIP-18_W7.62mm_Socket_LongPads

Connections:
+5V: C102.1, C104.1, D99.1 (K), D100.2 (A), D101.2 (A), D104.2 (A), D105.2 (A), D107.2 (A), D111.2 (A), D112.2 (A), D113.2 (A), D114.2 (A), D116.2 (A), J103.1, R103.1, U101.4 (V-), U102.3
/mode: R119.1, U102.9
GND: C101.2, C102.2, C104.2, D102.2 (A), J101.2, J102.2, J103.3, R108.2, U101.7 (V+), U102.2
unnamed: C101.1, C105.1, D102.1 (K), R13.1, R103.2, U101.3 (+), U102.4
unnamed: C103.1, R104.2, RV101.1, RV101.2, U101.2 (-)
unnamed: C103.2, R101.1, R102.1
unnamed: C105.2, R13.2, R106.1, U102.5
unnamed: D98.1 (K), R106.2, RV101.3
unnamed: D99.2 (A), J101.1
unnamed: D100.1 (K), R112.1
unnamed: D101.1 (K), R110.1
unnamed: D98.2 (A), D103.1 (K), U101.6
unnamed: D103.2 (A), R104.1
unnamed: D104.1 (K), R105.1
unnamed: D105.1 (K), R113.1
unnamed: D107.1 (K), R111.1
unnamed: D111.1 (K), R115.1
unnamed: D112.1 (K), R116.1
unnamed: D113.1 (K), R117.1
unnamed: D114.1 (K), R118.1
unnamed: D116.1 (K), R114.1
unnamed: J102.1, R101.2
unnamed: J102.3, R102.2
unnamed: J103.2, R119.2
unnamed: R105.2, U102.1
unnamed: R107.1, U102.6, U102.7
unnamed: R107.2, R108.1, U102.8
unnamed: R110.2, U102.18
unnamed: R111.2, U102.17
unnamed: R112.2, U102.16
unnamed: R113.2, U102.15
unnamed: R114.2, U102.14
unnamed: R115.2, U102.13
unnamed: R116.2, U102.12
unnamed: R117.2, U102.11
unnamed: R118.2, U102.10

Notes on the sheet:
Mechanical Holes
Mode Selector
PSU (Reverse Battery Protection)

Board: 2 copper layers, 50 parts (0 on the bottom side), 36 nets.

## Commit log

2025-01-17 Create Laboratorios
2025-01-17 Create Laboratorio_1
    Laboratório 1 - Introdução
2025-01-17 Rename Laboratorio_1 to Projeto
2025-01-17 Create Lab1
2025-02-01 readme.md
2025-02-02 main.c
    Ficheiro principal com todo o código
2025-02-02 Ficheiro principal do projeto, lógica do programa
2025-02-02 Ficheiro de cabeçalho. São declaradas as funções
2025-02-02 Manual Técnico e de Utilização
2025-02-02 Rename CTeSP/Introducao a Programacao/Laboratorios/Projeto/Readme.md to CTeSP/Introducao a Programacao/Projeto/Readme.md
2025-02-02 Rename CTeSP/Introducao a Programacao/Laboratorios/Projeto/Manual Técnico e de Utilização.pdf to CTeSP/Introducao a Programacao/Projeto/Manual Técnico e de Utilização.pdf
2025-02-02 Rename Manual Técnico e de Utilização.pdf to Mmmanual Técnico e de Utilização.pdf
2025-02-02 Relatório
2025-02-02 Create Laboratório 2
2025-02-03 Create Laboratório 1
2025-02-03 Create Lab3_Diogo_Silva_PSE_Ficheiros
2025-02-03 Rename Readme.md to Readme.md
2025-02-03 Create 0delelte
2025-02-03 Create Projeto
2025-02-05 Rename Lab 03 Diogo e Mussagy.pdf to Lab 03 Diogo e Mussagy.pdf
2025-02-05 Rename Lab 3.pka to Lab 3.pka
2025-02-05 Rename Lab 3b.pka to Lab 3b.pka
2025-02-05 Rename Lab 4 DiogoSilva_MussagyAbibo.pkt to Lab 4 DiogoSilva_MussagyAbibo.pkt
